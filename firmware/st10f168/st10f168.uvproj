# Keil uVision project st10f168.uvproj, settings and files
target Target 1 (166/167)
  device: ST10F168 STMicroelectronics
  cpu: IRAM (0xF600 - 0xFDFF) XRAM(0xD000-0xE7FF) IROM(0-0x3FFFF) ICAN(0xE800-0xEFFF) CLOCK(25000000) MOD167
  output: st10f168 +hex
  AfterMake: Z:\mnt\shared-ntfs\bin\win\hex2bin.exe Z:\mnt\shared-ntfs\sw\firmware\st10f168\Objects\st10f168.H86
  group st10f168
    ./: st10f168.a66
