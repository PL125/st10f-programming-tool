# Keil uVision project stage_1.uvproj, settings and files
target Target 1 (166/167)
  device: ST10F269 STMicroelectronics
  cpu: IRAM (0xF600 - 0xFDFF) XRAM (0xC000-0xDFFF) XRAM2(0xE000-0xE7FF) IROM(0-0x3FFFF) ICAN(0xE800-0xEFFF) CLOCK(40000000) MOD167
  output: stage_1 +hex
  AfterMake: Z:\mnt\shared-ntfs\bin\win\hex2bin.exe Z:\mnt\shared-ntfs\sw\firmware\stage_1\Objects\stage_1.H86
  group stage_1
    ./: stage_1.a66
